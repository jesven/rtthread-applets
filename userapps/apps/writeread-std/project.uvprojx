# Keil uVision project project.uvprojx, settings and files
target wfile (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: wrstd
  AfterMake: fromelf --bin !L --output app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\sdk\crt\armcc\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\project.sct
  group app
    ./: main.c
  group crt
    ../../sdk/crt/armcc/: retarget.c startup.S syscall.S crti.c
